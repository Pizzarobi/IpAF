<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Erster_Test.ewp</path>
  </project>
  <batchBuild />
</workspace>
